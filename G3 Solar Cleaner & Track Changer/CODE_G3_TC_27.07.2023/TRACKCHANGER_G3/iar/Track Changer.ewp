# IAR project Track Changer.ewp, settings and files
configuration release (ARM)
  General.OGChipSelectEditMenu: MK22FN1M0Axxx12 NXP MK22FN1M0Axxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MK22FN1M0AVLQ12
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ../CMSIS/Include; ../Source; ../Startup; ../Drivers; ../Utilities/io; ../Utilities/str; ../Utilities/log; ../Utilities; ..\Board; ..\Source\LTC4015; ..\Source\DELAY; ..\Source\DEBUG; ..\Source\OTHER; ..\Source\ADC; ..\Source\SPI; ..\Source\I2C; ..\Source\TEMP SENSORS; ..\Source\Communication; ..\Source\Communication\DebugUart; ..\Source\Communication\ZigbeeUart; ..\Source\Communication\ZigbeeApiMode; ..\ZigbeeAPILibrary; ..\Source; ..\Source\RobotControl; ..\Source\MotorControl\Motor1; ..\Source\MotorControl\Motor1\Pwm1; ..\Source\MotorControl\Motor2; ..\Source\MotorControl\Motor2\Pwm2; ..\Source\RotateSense; ..\Source\RobotOperation; ..\Source\DefaultValues; ..\Source\EdgeSensor; ..\Source\PortInterrupt; ..\Source\Relay; ..\Source\AutoMode; ..\Source\API PROCESSING; ..\Source\EEPROM; ..\Source\RobotOperation\CycleMode; ..\Source\RTC; ..\Source\MotorControl\BrushMotor; ..\Source\MotorControl\BrushMotor\BrushPwm; ..\Source\RobotControl\BrushControl; ..\Source\RobotOperation\AutoSchedule; ..\Source\RobotOperation\FaultProcess\OverCurrentFault; ..\Source\RobotOperation\FaultProcess; ..\Source\OTHER\LPTimer; ..\Source\LED; ..\Source\LED\LED1; ..\Source\LED\LED2; ..\Source\LED\LED3; ..\Source\OTHER\WDTimer; ..\Source\OTHER\VBatREG; ..\Source\Communication\ConfigUart; ..\Source\Communication\ConfigUart\ConfigUart API Process; ..\Source\Communication\ConfigUart\ConfigUart API Process\JsonParser; ..\Source\Event Logger; ..\Source\Proximity; ..\Source\SWITCH; ..\Source\RFID
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: TRACKCHANGER_SC_3.0V.hex
  ILINK.IlinkOutputFile: Solar_Robot_Board_Test1.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group board
    ../Board/: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group doc
    ../: readme.txt
  group drivers
    ../Drivers/: fsl_adc16.c fsl_adc16.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_dspi.c fsl_dspi.h fsl_flash.c fsl_flash.h fsl_ftm.c fsl_ftm.h fsl_gpio.c fsl_gpio.h fsl_i2c.c fsl_i2c.h fsl_lptmr.c fsl_lptmr.h fsl_port.h fsl_rcm.c fsl_rcm.h fsl_rtc.c fsl_rtc.h fsl_smc.c fsl_smc.h fsl_uart.c fsl_uart.h fsl_vref.c fsl_vref.h fsl_wdog.c fsl_wdog.h
  group source
    ../Source/: Customtypedefs.h RobotMain.c TempVariables.c TempVariables.h
  group source/ADC
    ../Source/ADC/: adc.c adc.h
  group source/API Processing
    ../Source/API PROCESSING/: APIProcessing.c APIProcessing.h ResponseAPIProcess.c ResponseAPIProcess.h ValuesValidate.c ValuesValidate.h
  group source/Communication
    ../Source/Communication/: CommCommon.c CommCommon.h
  group source/Communication/BmsUart
    ../Source/Communication/BmsUart/: BmsUart.c BmsUart.h BmsUart_Config.h
  group source/Communication/ConfigUart
    ../Source/Communication/ConfigUart/: ConfigUart.c ConfigUart.h ConfigUart_Config.h
  group source/Communication/ConfigUart/ConfigUart API Process
    ../Source/Communication/ConfigUart/ConfigUart API Process/: ConfigAPIProcess.c ConfigAPIProcess.h
  group source/Communication/ConfigUart/ConfigUart API Process/JSON Parser
    ../Source/Communication/ConfigUart/ConfigUart API Process/JsonParser/: fun_json.c fun_json.h json.c json.h
  group source/Communication/DebugUart
    ../Source/Communication/DebugUart/: DebugUart.c DebugUart.h DebugUart_Config.h
  group source/Communication/ZigbeeAPIMode
    ../Source/Communication/ZigbeeAPIMode/: ZigbeeAPIMode.c
    ../Source/Communication/ZigbeeApiMode/: ZigbeeApiMode.h
  group source/Communication/ZigbeeUart
    ../Source/Communication/ZigbeeUart/: ZigbeeUart.c ZigbeeUart.h ZigbeeUart_Config.h
  group source/DEBUG
    ../Source/DEBUG/: serial_debug.c Serial_Debug.h
  group source/DefaultValues
    ../Source/DefaultValues/: DefaultValues.c DefaultValues.h DefaultValuesConfig.h
  group source/DELAY
    ../Source/DELAY/: delay.c delay.h
  group source/EdgeSensor
    ../Source/EdgeSensor/: EdgeSense1.c EdgeSense1.h EdgeSense2.c EdgeSense2.h EdgeSenseCommon.c EdgeSenseCommon.h
  group source/EEPROM
    ../Source/EEPROM/: eeprom.c eeprom.h EepromMain.c eeprommain.h eepromStdtoHalDriver.c eepromStdtoHalDriver.h eepromStore.c EepromStore.h usr_flash.c usr_flash.h
  group source/EventLogger
    ../Source/Event Logger/: EventLogger.c EventLogger.h EventLoggerFlash.c EventLoggerFlash.h
  group source/I2C
    ../Source/I2C/: i2c_init.c i2c_init.h
  group source/LED
    ../Source/LED/: LedCommon.c LedCommon.h
  group source/LED/LED1
    ../Source/LED/LED1/: Led1.c Led1.h
  group source/LED/LED2
    ../Source/LED/LED2/: Led2.c Led2.h
  group source/LED/LED3
    ../Source/LED/LED3/: Led3.c Led3.h
  group source/LTC4015
    ../Source/LTC4015/: bat_i2c.C bat_i2c.h LTC4015.c LTC4015.h LTC4015_formats.h LTC4015_main.c LTC4015_Main.h LTC4015_reg_defs.h store_soc.c store_soc.h
  group source/MotorControl/BrushMotor
    ../Source/MotorControl/BrushMotor/: BrushMotorControl.c BrushMotorControl.h BrushMotorControl_Config.h BrushMotorControl_hal.c BrushMotorControl_hal.h
  group source/MotorControl/BrushMotor/BrushPwm
    ../Source/MotorControl/BrushMotor/BrushPwm/: BrushPwm.c BrushPwm.h BrushPwm_Config.h
  group source/MotorControl/Motor1
    ../Source/MotorControl/Motor1/: Motor1Control.c Motor1Control.h Motor1Control_Config.h Motor1Control_hal.c Motor1Control_hal.h
  group source/MotorControl/Motor1/Pwm1
    ../Source/MotorControl/Motor1/Pwm1/: Pwm1.c Pwm1.h Pwm1_Config.h
  group source/MotorControl/Motor2
    ../Source/MotorControl/Motor2/: Motor2Control.c Motor2Control.h Motor2Control_Config.h Motor2Control_hal.c Motor2Control_hal.h
  group source/MotorControl/Motor2/Pwm2
    ../Source/MotorControl/Motor2/Pwm2/: Pwm2.c Pwm2.h Pwm2_Config.h
  group source/OTHER
    ../Source/OTHER/: NumStrConversion.c NumStrConversion.h
  group source/OTHER/LPTimer
    ../Source/OTHER/LPTimer/: LPTimer.c LPTimer.h
  group source/OTHER/VBatREG
    ../Source/OTHER/VBatREG/: VBatReg.c VBatReg.h
  group source/OTHER/WDTimer
    ../Source/OTHER/WDTimer/: WDTimer.c WDTimer.h
  group source/PortInterrupt
    ../Source/PortInterrupt/: PortInterrupt.c PortInterrupt.h
  group source/PROXIMITY
    ../Source/PROXIMITY/: cleanerdetect1.c cleanerdetect2.c cleanerdetectcommon.c proximity.c
    ../Source/Proximity/: cleanerdetect1.h cleanerdetect2.h cleanerdetectcommon.h proximity.h
  group source/Relay
    ../Source/Relay/: Relay.c Relay.h
  group source/RFID
    ../Source/RFID/: rfid.c rfid.h RfidUart_Config.h
  group source/RobotControl
    ../Source/RobotControl/: RobotControl.c RobotControl.h
  group source/RobotControl/BrushControl
    ../Source/RobotControl/BrushControl/: BrushControl.c BrushControl.h
  group source/RobotOperation
    ../Source/RobotOperation/: RobotOperation.c RobotOperation.h
  group source/RobotOperation/AutoSchedule
    ../Source/RobotOperation/AutoSchedule/: AutoSchedule.c AutoSchedule.h
  group source/RobotOperation/CycleMode
    ../Source/RobotOperation/CycleMode/: CycleMode.c CycleMode.h
  group source/RobotOperation/FaultProcess
    ../Source/RobotOperation/FaultProcess/: FaultProcess.c FaultProcess.h
  group source/RobotOperation/FaultProcess/OverCurrentFault
    ../Source/RobotOperation/FaultProcess/OverCurrentFault/: Mot1CurrentFault.c Mot1CurrentFault.h Mot2CurrentFault.c Mot2CurrentFault.h Mot3CurrentFault.c Mot3CurrentFault.h MotCurrentFaultCommon.c MotCurrentFaultCommon.h
  group source/RotateSense
    ../Source/RotateSense/: QuadDecoder.c QuadDecoder.h RotateSense1.c RotateSense1.h RotateSense2.c RotateSense2.h RotateSenseCommon.c RotateSenseCommon.h
  group source/RTC
    ../Source/RTC/: Rtc.c Rtc.h
  group source/SDFAT
    ../Source/SDFAT/: diskio.c diskio.h ff.c ff.h ffconf.h integer.h SDcardoperation.c SDcardoperation.h
  group source/SPI
    ../Source/SPI/: PwmDriveSpi.c PwmDriveSpi.h spi.c spi.h
  group source/SWITCH
    ../Source/SWITCH/: switch.c switch.h
  group source/TEMP SENSOR
    ../Source/TEMP SENSORS/: temp_sensors.c temp_sensors.h
  group source/ZigbeeApiLibrary
    ../ZigbeeAPILibrary/: XbeeZigbeeAPI.a ZigbeeAPI.h
  group startup
    ../Startup/: startup_MK22FA12.s system_MK22FA12.c system_MK22FA12.h
  group utilities
    ../Utilities/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../Utilities/io/: fsl_io.c fsl_io.h
    ../Utilities/log/: fsl_log.c fsl_log.h
    ../Utilities/str/: fsl_str.c fsl_str.h
